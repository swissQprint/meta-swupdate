require swupdate.inc

SRCREV = "33c5688590e811c9d54101accc6ea368ea5f0f50"

SRC_URI += "file://0001-Feature-Add-HTTP-Put-request-to-swupdate-progress-to.patch \
